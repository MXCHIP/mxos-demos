# IAR project demo.ewp, settings and files
configuration MiCOKit-3165 (ARM)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; HSE_VALUE=26000000
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\Demos\helloworld; ..\..\..\..\include; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\MiCOKit-3165; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\Platform\Drivers; ..\..\..\..\mico\system; ..\..\..\..\libraries\utilities\json_c; ..\..\..\..\libraries\utilities; ..\..\..\..\libraries\daemons\http_server; ..\..\..\..\mico\security; ..\..\..\..\libraries\daemons\homekit_server
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MiCOKit-3165\micoLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MiCOKit-3288 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; HSE_VALUE=16000000
  ICCARM.CCIncludePath2: ..\..\..\..\Demos\helloworld; ..\..\..\..\include; ..\..\..\..\Board\MiCOKit-3288; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\Platform\Drivers\MiCOKit_EXT; ..\..\..\..\MICO; ..\..\..\..\libraries\protocols; ..\..\..\..\libraries\utilities; ..\..\..\..\mico\system; ..\..\..\..\libraries\daemons\http_server; ..\..\..\..\mico\security; ..\..\..\..\Platform\Drivers; ..\..\..\..\libraries\daemons\homekit_server
  ILINK.IlinkOutputFile: COM.MXCHIP.BASIC.out
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MiCOKit-3288\micoLinkerForIAR.icf
configuration NUCLEO_F411RE (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\Demos\helloworld; ..\..\..\..\include; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\Platform\Drivers; ..\..\..\..\mico\system; ..\..\..\..\libraries\utilities\json_c; ..\..\..\..\libraries\utilities; ..\..\..\..\libraries\daemons\http_server; ..\..\..\..\mico\security; ..\..\..\..\Board\NUCLEO_F411RE; ..\..\..\..\libraries\daemons\homekit_server
  ILINK.IlinkIcfFile: ..\..\..\..\Board\NECLEO_F411RE\micoLinkerForIAR.icf
configuration MiCOKit-3238 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; HSE_VALUE=26000000; DEBUG; BUILDCFG; BLUETOOTH_BTE; GATT_ENABLE
  ICCARM.CCDiagSuppress: Pa050, Pe301
  ICCARM.CCIncludePath2: ..\..\..\..\Demos\test\bt_mfg_test; ..\..\..\..\include; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\MK3238; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\Platform\Drivers; ..\..\..\..\mico\system; ..\..\..\..\libraries\utilities\json_c; ..\..\..\..\libraries\utilities; ..\..\..\..\libraries\daemons\http_server; ..\..\..\..\mico\security; ..\..\..\..\libraries\daemons\homekit_server; ..\..\..\..\libraries\protocols\gagent\inc; ..\..\..\..\libraries\bluetooth\include; ..\..\..\..\libraries\daemons\bt_smartbridge\include; ..\..\..\..\libraries\daemons\bt_smartbridge\internal; ..\..\..\..\libraries\daemons\bt_smart_controller; D:\Workspace\MiCO\libraries\drivers
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MiCOKit-3238\micoLinkerForIAR.icf
configuration BTE (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; HSE_VALUE=26000000; mxos_BLE; DEBUG; BUILDCFG
  ICCARM.CCIncludePath2: ..\..\..\..\Demos\mble\wlan_config; ..\..\..\..\include; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\MiCOKit-3238; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\Platform\Drivers; ..\..\..\..\mico\system; ..\..\..\..\libraries\utilities\json_c; ..\..\..\..\libraries\utilities; ..\..\..\..\libraries\daemons\http_server; ..\..\..\..\mico\security; ..\..\..\..\libraries\daemons\homekit_server; ..\..\..\..\libraries\protocols\gagent\inc; ..\..\..\..\libraries\bluetooth\include; ..\..\..\..\libraries\bluetooth\BTE\Projects\bte\main; ..\..\..\..\libraries\bluetooth\BTE\Components\stack\include; ..\..\..\..\libraries\bluetooth\include; ..\..\..\..\libraries\bluetooth; ..\..\..\..\libraries\bluetooth\BTE\mico
  ILINK.IlinkIcfFile: as above
configuration MiCOKit-3239 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F412RG ST STM32F412RG
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; HSE_VALUE=26000000; STM32F412xG; DEBUG; BUILDCFG; BLUETOOTH_BTE; GATT_ENABLE
  ICCARM.CCDiagSuppress: Pa050, Pe301
  ICCARM.CCIncludePath2: ..\..\..\..\Demos\test\bt_mfg_test; ..\..\..\..\include; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\board\MK3239; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\Platform\Drivers; ..\..\..\..\mico\system; ..\..\..\..\libraries\utilities\json_c; ..\..\..\..\libraries\utilities; ..\..\..\..\libraries\daemons\http_server; ..\..\..\..\mico\security; ..\..\..\..\libraries\daemons\homekit_server; ..\..\..\..\libraries\protocols\gagent\inc; ..\..\..\..\libraries\bluetooth\include; ..\..\..\..\libraries\daemons\bt_smartbridge\include; ..\..\..\..\libraries\daemons\bt_smartbridge\internal; ..\..\..\..\libraries\daemons\bt_smart_controller; ..\..\..\..\libraries\drivers
  ILINK.IlinkIcfFile: as above
  group Application
    ../: bt_bus.c bt_bus.h bt_firmware.c bt_firmware.h bt_hci.c bt_hci.h bt_hci_interface.h bt_mfg_test.c bt_mfg_test.h bt_mfg_test_main.c bt_packet.c bt_packet_internal.h bt_transport_driver.c bt_transport_driver.h bt_transport_driver_receive.c bt_transport_thread.c bt_transport_thread.h mxos_config.h
    ../../../../libraries/bluetooth/firmware/43438A0/: bt_firmware_image.c
    ../../../../libraries/bluetooth/firmware/43438A1/26MHz/: bt_firmware_image.c
  group Board/MiCOKit-3165
    ../../../../Board/MiCOKit-3165/: platform.c platform.h platform_config.h
  group Board/MiCOKit-3238
    ../../../../Board/MiCOKit-3238/: platform.c platform.h platform_config.h wifi_nvram.c wifi_nvram_image.h
  group Board/MiCOKit-3239
    ../../../../board/MK3239/: platform.c wifi_nvram.c
  group Board/MiCOKit-3288
    ../../../../Board/MiCOKit-3288/: platform.c platform.h platform_config.h
  group Board/NUCLEO_F411RE
    ../../../../board/NUCLEO_F411RE/: platform.c platform.h platform_config.h
  group include
    ../../../../include/: common.h debug.h mico.h mxos_platform.h mxos_rtos.h mxos_security.h mxos_socket.h mxos_system.h mxos_wlan.h
  group include/MicoDriver
    ../../../../include/MiCODrivers/: MiCODriverAdc.h MiCODriverGpio.h MiCODriverI2c.h MiCODriverMFiAuth.h MiCODriverPwm.h MiCODriverRng.h MiCODriverRtc.h MiCODriverSpi.h MiCODriverUart.h MiCODriverWdg.h
  group libraries/bluetooth
    ../../../../libraries/bluetooth/BTE/: BTE.a
  group libraries/bluetooth/BTE/Components/gki
    ../../../../libraries/bluetooth/BTE/Components/gki/common/: gki_buffer.c gki_debug.c gki_time.c
    ../../../../libraries/bluetooth/BTE/Components/gki/mico/: gki_mico.c
  group libraries/bluetooth/BTE/Components/hcis
    ../../../../libraries/bluetooth/BTE/Components/hcis/: hcill_proto.c hcilp.c hcisu_h4.c hciutil.c
  group libraries/bluetooth/BTE/Components/stack/brcm
    ../../../../libraries/bluetooth/BTE/Components/stack/brcm/: brcm_ble.c brcm_prm.c brcm_tbfc.c bte_brcm.c
  group libraries/bluetooth/BTE/Components/stack/btm
    ../../../../libraries/bluetooth/BTE/Components/stack/btm/: btm_acl.c btm_ble.c btm_ble_addr.c btm_ble_bgconn.c btm_ble_gap.c btm_ble_privacy.c btm_cfg.c btm_dev.c btm_devctl.c btm_inq.c btm_main.c btm_pm.c btm_sco.c btm_sec.c btm_sec_nvram.c
  group libraries/bluetooth/BTE/Components/stack/btu
    ../../../../libraries/bluetooth/BTE/Components/stack/btu/: btu_hcif.c btu_init.c btu_task.c
  group libraries/bluetooth/BTE/Components/stack/gap
    ../../../../libraries/bluetooth/BTE/Components/stack/gap/: gap_api.c gap_ble.c gap_conn.c gap_utils.c
  group libraries/bluetooth/BTE/Components/stack/gatt
    ../../../../libraries/bluetooth/BTE/Components/stack/gatt/: att_protocol.c gatt_api.c gatt_attr.c gatt_auth.c gatt_cl.c gatt_main.c gatt_sr.c gatt_utils.c
    ../../../../libraries/bluetooth/BTE/Components/stack/gatt/legattdb/: legattdb.c
  group libraries/bluetooth/BTE/Components/stack/hcic
    ../../../../libraries/bluetooth/BTE/Components/stack/hcic/: hciblecmds.c hcicmds.c
  group libraries/bluetooth/BTE/Components/stack/l2cap
    ../../../../libraries/bluetooth/BTE/Components/stack/l2cap/: l2c_api.c l2c_ble.c l2c_ble_conn.c l2c_ble_utils.c l2c_csm.c l2c_fcr.c l2c_link.c l2c_main.c l2c_utils.c
  group libraries/bluetooth/BTE/Components/stack/rfcomm
    ../../../../libraries/bluetooth/BTE/Components/stack/rfcomm/: port_api.c port_rfc.c port_utils.c rfc_l2cap_if.c rfc_mx_fsm.c rfc_port_fsm.c rfc_port_if.c rfc_ts_frames.c rfc_utils.c
  group libraries/bluetooth/BTE/Components/stack/sdp
    ../../../../libraries/bluetooth/BTE/Components/stack/sdp/: sdp_api.c sdp_db.c sdp_discovery.c sdp_main.c sdp_server.c sdp_utils.c
  group libraries/bluetooth/BTE/Components/stack/smp
    ../../../../libraries/bluetooth/BTE/Components/stack/smp/: aes.c p_256_curvepara.c p_256_ecc_pp.c p_256_multprecision.c smp_act.c smp_api.c smp_br_main.c smp_cmac.c smp_keys.c smp_l2c.c smp_main.c smp_utils.c
  group libraries/bluetooth/BTE/Components/stack/wbt
    ../../../../libraries/bluetooth/BTE/Components/stack/wbt/: wbt_ext.c
  group libraries/bluetooth/BTE/Components/udrv
    ../../../../libraries/bluetooth/BTE/Components/udrv/mico/: userial_mico.c
  group libraries/bluetooth/BTE/gki
    ../../../../libraries/bluetooth/BTE/Components/gki/common/: gki.h gki_common.h
  group libraries/bluetooth/BTE/mxos_bt_api
    ../../../../libraries/bluetooth/BTE/mxos_bt_api/: mxos_bt_ble_wrapper.c mxos_bt_dev_wrapper.c mxos_bt_gatt.c mxos_bt_gatt_wrapper.c mxos_bt_hidd_ble_wrapper.c mxos_bt_int.h mxos_bt_l2c_le_wrapper.c mxos_bt_l2c_wrapper.c mxos_bt_main.c mxos_bt_rfcomm_wrapper.c mxos_bt_sco_wrapper.c mxos_bt_sdp_wrapper.c
  group libraries/bluetooth/BTE/Projects
    ../../../../libraries/bluetooth/BTE/Projects/bte/main/: bte_hcisu.c bte_init.c bte_load.c bte_version.c
    ../../../../libraries/bluetooth/BTE/Projects/bte/embedded/mico/lib/: mxos_post_reset.c
  group libraries/bluetooth/BTE/proto_disp
    ../../../../libraries/bluetooth/BTE/proto_disp/: hcidisp.c
  group libraries/bluetooth/mxos_bt_platform
    ../../../../libraries/bluetooth/BTE/mxos_bt_platform/: mxos_bt_bus.c mxos_bt_hcd.c mxos_bt_logmsg.c mxos_bt_nvram_access.c mxos_upio.c
  group libraries/daemons/bt_smart_controller
    ../../../../libraries/daemons/bt_smart_controller/: bt_smart.c bt_smart.h bt_smart_server.c bt_smart_server_cache.c
  group libraries/daemons/bt_smartbridge
    ../../../../libraries/daemons/bt_smartbridge/: mxos_bt_management.c mxos_bt_smartbridge.c mxos_bt_smartbridge_cfg.c mxos_bt_smartbridge_gatt.c
  group libraries/daemons/bt_smartbridge/include
    ../../../../libraries/daemons/bt_smartbridge/include/: mxos_bt.h mxos_bt_smart_attribute.h mxos_bt_smart_interface.h mxos_bt_smartbridge.h mxos_bt_smartbridge_constants.h mxos_bt_smartbridge_gatt.h
  group libraries/daemons/bt_smartbridge/internal
    ../../../../libraries/daemons/bt_smartbridge/internal/: bt_smart_attribute.c bt_smartbridge_att_cache_manager.c bt_smartbridge_att_cache_manager.h bt_smartbridge_helper.c bt_smartbridge_helper.h bt_smartbridge_socket_manager.c bt_smartbridge_socket_manager.h bt_smartbridge_stack_interface.c bt_smartbridge_stack_interface.h
  group libraries/daemons/homekit_server
    ../../../../libraries/daemons/homekit_server/: libHomeKit_CM4.a
  group libraries/daemons/http_server
    ../../../../libraries/daemons/http_server/: http-strings.c http-strings.h http_parse.c http_parse.h httpd.c httpd.h httpd_handle.c httpd_priv.h httpd_ssi.c httpd_sys.c httpd_wsgi.c
  group libraries/Drivers/display/VGM128064
    ../../../../libraries/drivers/display/VGM128064/: AsciiLib.c AsciiLib.h oled.c oled.h oledfont.h
  group libraries/Drivers/keypad/gpio_button
    ../../../../libraries/drivers/keypad/gpio_button/: button.c button.h
  group libraries/Drivers/led/P9813
    ../../../../libraries/drivers/rgb_led/P9813/: hsb2rgb_led.c hsb2rgb_led.h rgb_led.c rgb_led.h
  group libraries/Drivers/MFiAuth
    ../../../../libraries/drivers/MiCODriverMFiAuth/: MiCODriverMFiAuth.a
  group libraries/Drivers/MiCOKit-EXT
    ../../../../libraries/drivers/MiCOKit_EXT/: micokit_ext.c micokit_ext.h micokit_ext_def.h micokit_ext_mfg.c motion_sensor.c motion_sensor.h temp_hum_sensor.c temp_hum_sensor.h
  group libraries/Drivers/MiCOKit-STmem
    ../../../../libraries/drivers/MiCOKit_STmems/: MiCOKit_STmems.c MiCOKit_STmems.h MiCOKit_STmems_def.h
  group libraries/Drivers/motor/dc_motor
    ../../../../libraries/drivers/motor/dc_motor/: dc_motor.c dc_motor.h
  group libraries/Drivers/sensor/ADPS9930
    ../../../../libraries/drivers/sensor/APDS9930/: APDS9930.c APDS9930.h
  group libraries/Drivers/sensor/BMA2X2
    ../../../../libraries/drivers/sensor/BMA2x2/: bma2x2.c bma2x2.h bma2x2_user.c bma2x2_user.h
  group libraries/Drivers/sensor/BME280
    ../../../../libraries/drivers/sensor/BME280/: bme280.c bme280.h bme280_user.c bme280_user.h
  group libraries/Drivers/sensor/BMG160
    ../../../../libraries/drivers/sensor/BMG160/: bmg160.c bmg160.h bmg160_user.c bmg160_user.h
  group libraries/Drivers/sensor/BMM050
    ../../../../libraries/drivers/sensor/BMM050/: bmm050.c bmm050.h bmm050_user.c bmm050_user.h
  group libraries/Drivers/sensor/DHT11
    ../../../../libraries/drivers/sensor/DHT11/: DHT11.c DHT11.h
  group libraries/Drivers/sensor/HTS221
    ../../../../libraries/drivers/sensor/HTS221/: hts221.c hts221.h
  group libraries/Drivers/sensor/infrared_adc
    ../../../../libraries/drivers/sensor/infrared_adc/: infrared_reflective.c infrared_reflective.h
  group libraries/Drivers/sensor/light_adc
    ../../../../libraries/drivers/sensor/light_adc/: light_sensor.c light_sensor.h
  group libraries/Drivers/sensor/LPS25HB
    ../../../../libraries/drivers/sensor/LPS25HB/: lps25hb.c lps25hb.h
  group libraries/Drivers/sensor/LSM9DS1
    ../../../../libraries/drivers/sensor/LSM9DS1/: lsm9ds1.h lsm9ds1_acc_gyr.c lsm9ds1_mag.c
  group libraries/Drivers/sensor/UVIS25
    ../../../../libraries/drivers/sensor/UVIS25/: uvis25.c uvis25.h
  group libraries/Drivers/SPI Flash
    ../../../../libraries/drivers/spi_flash/: spi_flash.c spi_flash.h spi_flash_internal.h spi_flash_platform.c spi_flash_platform_interface.h
  group libraries/protocols/gagent
    ../../../../libraries/protocols/gagent/: gagent_cloud_cm4_debug.a gagent_cloud_cm4_release.a
  group libraries/utilities
    ../../../../libraries/utilities/: AESUtils.c CheckSumUtils.c HTTPUtils.c LinkListUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
  group libraries/utilities/json_c
    ../../../../libraries/utilities/json_c/: arraylist.c arraylist.h bits.h config.h json.h json_debug.c json_debug.h json_inttypes.h json_object.c json_object.h json_object_private.h json_tokener.c json_tokener.h json_util.c json_util.h linkhash.c linkhash.h printbuf.c printbuf.h
  group mico/core
    ../../../../MICO/core/: mxos_config.c mxchipWNet_cm4f_8801.a mxchipWNet_cm4f_sdio.a mxchipWNet_cm4f_spi.a
    ../../../../MICO/core/RF driver/: wlan_firmware.c
  group mico/security
    ../../../../MICO/security/: MicoCrypto.a MicoSrpServer.a
  group mico/security/curve25519
    ../../../../MICO/security/Curve25519/: curve25519-donna.c
  group mico/security/SHA
    ../../../../MICO/security/SHAUtils/: hkdf.c hmac.c sha1.c sha224-256.c sha384-512.c usha.c
  group mico/system
    ../../../../MICO/system/config_server/: config_server.c config_server_menu.c
    ../../../../MICO/system/command_console/: mxos_cli.c mxos_cli.h
    ../../../../MICO/system/: mxos_system_init.c mxos_system_monitor.c mxos_system_notification.c mxos_system_para_storage.c mxos_system_power_daemon.c system.h system_factory_test.c system_misc.c
    ../../../../MICO/system/tftp_ota/: tftp.h tftp_ota.c tftp_ota.h tftpc.o
  group mico/system/bluetooth
    ../../../../mico/system/bluetooth/: mble_cfg.c mble_gatt_db.c mble_gatt_db.h system_bt.c
  group mico/system/easylink
    ../../../../MICO/system/easylink/airkiss_discovery/: airkiss_discovery.c
    ../../../../MICO/system/easylink/airkiss_discovery/lib_airkiss/: libairkiss.a
    ../../../../MICO/system/easylink/: libMFiWAC.a system_easylink.c system_easylink_delegate.c system_easylink_wac.c
  group mico/system/mdns
    ../../../../MICO/system/mdns/: mxos_mdns.c mxos_mdns.h system_discovery.c
  group Platform
    ../../../../Platform/MCU/: mxos_platform_common.c wlan_platform_common.c
  group Platform/Cortex-M4
    ../../../../Platform/Cortex-M4/: crt0_EWARM.c hardfault.c
  group Platform/EWARM
    ../../../../Platform/EWARM/: Retarget.c
  group Platform/STM32F4xx
    ../../../../Platform/MCU/STM32F4xx/: platform_init.c
  group Platform/STM32F4xx/EWARM
    ../../../../Platform/MCU/STM32F4xx/EWARM/: startup_stm32f411xe_IAR.s
  group Platform/STM32F4xx/Peripherals
    ../../../../Platform/MCU/STM32F4xx/peripherals/: platform_adc.c platform_flash.c platform_gpio.c platform_i2c.c platform_mcu_powersave.c platform_nano_second.c platform_pwm.c platform_rng.c platform_rtc.c platform_spi.c platform_uart.c platform_watchdog.c
  group Platform/STM32F4xx/Peripherals/Libraries
    ../../../../Platform/MCU/STM32F4xx/peripherals/libraries/: system_stm32f4xx.c
  group Platform/STM32F4xx/Peripherals/Libraries/STM32F4xx_StdPeriph_Driver
    ../../../../Platform/MCU/STM32F4xx/peripherals/libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Platform/STM32F4xx/Wi-Fi_Bus_Driver
    ../../../../Platform/MCU/STM32F4xx/wlan_bus_driver/: wlan_bus_SDIO.c wlan_bus_SPI.c wlan_platform.c
